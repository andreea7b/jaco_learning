Commit message: robothas a cup, plotting goals as well

File: data/resources/dinnerware/cup/cup_small.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: mass .1 -> 0.000001
